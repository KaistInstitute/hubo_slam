Commit message: adding 2D slam. final for robot world demo

File: urdf/hubo_3d.urdf (robot description, URDF)
Before this commit: robot hubo_3d, 3 links, 2 joints
Joints:
- joint imu_link_joint: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 0 rpy=3.1416 0 0
